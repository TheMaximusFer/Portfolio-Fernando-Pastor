# Keil uVision project blink_nrf.uvprojx, settings and files
target nRF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.59.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: blink_nrf +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --diag_suppress=2803,1296
  c include: ../src_nrf;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  scatter file: .\nrf52840_minimal.sct
  group Source Comun
    ../../src/: main.c drv_leds.c drv_leds.h drv_tiempo.c drv_tiempo.h hal_gpio.h hal_tiempo.h board.h drv_consumo.h drv_consumo.c hal_consumo.h drv_monitor.h drv_monitor.c rt_fifo.h rt_evento_t.h rt_fifo.c rt_GE.c rt_GE.h svc_GE.h svc_alarmas.c svc_alarmas.h svc_GE.c drv_botones.c drv_botones.h hal_ext_int.h drv_WDT.c drv_WDT.h hal_WDT.h rt_sc.h juego_counter.c juego_counter.h juego_beat.c drv_random.c drv_random.h hal_random.h
  group Dependientes
    ../src_nrf/: hal_gpio_nrf.c hal_tiempo_nrf.c board_nrf52840dk.h board_nrf52840_dongle.h hal_consumo_nrf.c hal_ext_int_nrf.c rt_sc_nrf.c hal_WDT_nrf.c hal_random_nrf.c
software components: CMSIS:CORE 5.1.2, Device:Startup 8.59.0, Device:StartupConfig 8.59.0
